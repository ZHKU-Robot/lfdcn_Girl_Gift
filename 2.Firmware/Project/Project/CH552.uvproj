# Keil uVision project CH552.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH551 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0xFF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: Girl's_Gift +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Public;..\User\GPIO;..\User\PWM;..\User\Timer;..\User\ADC;..\User\Compare;..\User\DataFlash;..\User\IAP;..\User\SPI;..\User\TouchKey;..\User\USB\USB_LIB;..\User\IIC;..\User\UART;..\User\Timer;..\User\RZ
  group Source Group 1
    ./: main.c
    ../Public/: Debug.C
    ../User/GPIO/: GPIO.C
    ../User/IIC/: I2C.C
    ../User/Timer/: Timer.C
    ../User/UART/: UART.C
    ../User/RZ/: RZ.C
